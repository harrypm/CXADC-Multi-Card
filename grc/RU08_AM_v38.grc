options:
  parameters:
    generate_options: qt_gui
    id: RU08_AM_v38
    output_language: python
    title: RU08 AM Demod
  states: {}

blocks:
- name: adc_freq
  id: variable
  parameters:
    value: '28800000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '500000'
    step: '1000'
    stop: '1800000'
    value: '1000000'
    widget: counter
  states: {}
- name: decim_rate
  id: variable
  parameters:
    comment: samp_rate/192k
    value: '150'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: adc_freq / 2
    step: adc_freq / 4
    stop: adc_freq / 4 * 5
    value: adc_freq
    widget: counter
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: decim_rate
    gain: '1'
    high_cutoff_freq: center_freq + 5000
    low_cutoff_freq: center_freq - 5000
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/swradio0
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [band_pass_filter_0, '0', analog_agc_xx_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', band_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
